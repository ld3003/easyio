# Keil uVision project OTAProject.uvprojx, settings and files
target rtthread-stm32l (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin -o./binfile/bootloader.bin ./output_ota/bootloader.axf
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,FRQL,BOOTLOADER
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;.\Libraries\CMSIS\Device\ST\STM32L1xx\Include;.\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\easyio_core;drivers;..\..\components\net\lwip\src\include;..\..\components\net\lwip;..\..\components\net\lwip\src;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\easyio_core;..\easyio_core\nmealib\include;.\drivers\extdrv;.\applications
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Drivers
    drivers/: board.c
    ./drivers/extdrv/: IOI2C.c watch_dog.c w25q16.c flash_opt.c led.c
    ./drivers/: bootloader_usart.c
  group STM32_StdPeriph
    ./Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c misc.c
    ./Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ./Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_hd.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
  group Components
    ../../components/init/: components.c
  group MY_STD_FUNC
    ../easyio_core/my_stdc_func/: my_stdc_func.c debugl.c
  group MD5
    ../easyio_core/MD5/: md5sum.c
  group README
    ./: readme.txt
  group applications
    ./applications/: application.c startup.c bootloader_main.c spiflash_config.c
  group AppEV
    ../easyio_core/: app_ev.c app_timer.c
  group json
    ../easyio_core/json/: cJSON.c
