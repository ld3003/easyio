# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32l (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32 +hex
  AfterMake: fromelf.exe --bin -o./output/rtthread.bin ./build/rtthread-stm32.axf
  c flags: Optim=1
  c define: xSTM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;.\Libraries\CMSIS\Device\ST\STM32L1xx\Include;.\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\easyio_core;drivers;..\..\components\net\lwip\src\include;..\..\components\net\lwip;..\..\components\net\lwip\src;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\easyio_core;..\easyio_core\nmealib\include;.\drivers\extdrv;.\applications
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group easyio_core
    ../easyio_core/: lwip_raw_api_tcp_template.c modem_serial.c at_cmd.c app_ev.c serial_srv.c app_timer.c common.h
  group Drivers
    drivers/: board.c usart.c
    ./drivers/extdrv/: flash_opt.c gnss.c IOI2C.c led.c MMA845X.c sim900.c watch_dog.c adc.c w25q16.c stabdby.c
  group STM32_StdPeriph
    ./Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c misc.c
    ./Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ./Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_hd.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
  group Components
    ../../components/init/: components.c
  group Lwip_PPP
    ../../components/net/lwip/src/api/: api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c api_lib.c
    ../../components/net/lwip/src/arch/: sys_arch.c
    ../../components/net/lwip/src/core/: def.c dns.c init.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c memp.c
    ../../components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c randm.c vj.c
    ../../components/net/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../components/net/lwip/src/netif/: etharp.c slipif.c
  group XMPP
    ../easyio_core/XMPP/: xmpp.c xmpp_helper.c
  group XML
    ../easyio_core/XML/: ezxml.c
  group BASE64
    ../easyio_core/BASE64/: cbase64.c
  group MY_STD_FUNC
    ../easyio_core/my_stdc_func/: my_stdc_func.c debugl.c
  group nmealib
    ../easyio_core/nmealib/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c tok.c time.c
  group SHA1
    ../easyio_core/SHA1/: sha1.c shatest.c
  group CMUX
    ../easyio_core/gsmmux/: buffer.c gsm0710.c easyio_cmux.c
  group MD5
    ../easyio_core/MD5/: md5sum.c
  group README
    ./: develop_log.txt
  group applications
    ./applications/: application.c ppp_service.c startup.c global_env.c process_xmpp.c ublox_gps.c ublox_serial.c xmpp_msg_queue.c xmpp_tcp.c lowpower.c spiflash_config.c ota_http_tcp.c gps_tracker.c test_hw.c sms.c movecall.c sosapp.c
  group cJSON
    ../easyio_core/json/: cJSON.c
target rtthread-stm32l-ota (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: rtthread-stm32 +hex
  AfterMake: fromelf.exe --bin -o./binfile/fw.bin ./output_fw/rtthread-stm32.axf
  AfterMake: .\hex2cRelease\hex2c.exe
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,ENABLE_OTA
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
